# Keil uVision project display_cube.uvprojx, settings and files
target Target (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: display_cube
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AIR001_DEV
  c include: ..\User;..\Libraries\AIR001xx_HAL_Driver\Inc;..\Libraries\AIR001xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group FWLB
    ../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_dma.c air001xx_hal_exti.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_spi.c air001xx_hal_spi_ex.c air001xx_hal_tim.c air001xx_hal_tim_ex.c
  group USER
    ../User/: main.c air001xx_it.c air001xx_hal_msp.c oled.c
software components: CMSIS:CORE 4.3.0, Device:Startup 0.0.1
